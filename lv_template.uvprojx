# Keil uVision project lv_template.uvprojx, settings and files
target Cortex-M33_MPS3 (6210000::V6.21::ARMCLANG)
  device: IOTKit_CM33_FP ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.5.0
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28200000,0x00200000) IROM(0x10000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: lv_template
  c flags: OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: COMPILER_FLAGS=\"-Omax\"
  c misc: -Wno-format -Omax
  c include: .\platform;.
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  scatter file: .\RTE\Device\IOTKit_CM33_FP\ac6_arm.sct
  group platform
    ./platform/: serial.c serial.h platform.c platform.h
  group Documentation
    ./: Abstract.txt
  group application
    ./: main.c app_cfg.h
target Cortex-M33 FVP (6210000::V6.21::ARMCLANG)
  device: IOTKit_CM33_FP ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.5.0
  cpu: as above
  output: lv_template
  c flags: OneElfS=1 v6Lang=6 v6LangP=3 v6Lto=1 wLevel=3
  c define: COMPILER_FLAGS=\"-Omax\"
  c misc: -Wno-format -Omax
  c include: .\platform;.
  memory RVCT4: ROM 0x10000000 size 0x200000
  memory RVCT5: ROM 0x200000 size 0x200000
  memory RVCT9: RAM 0x38000000 size 0x200000
  memory RVCT10: RAM 0x28200000 size 0x200000
  scatter file: .\RTE\Device\IOTKit_CM33_FP\ac6_arm.sct
software components: CMSIS Driver:USART:Custom 1.0.0, CMSIS:CORE 6.0.0, Utilities:perf_counter:Benchmark 1.1.2, Utilities:perf_counter:Core 2.3.0, Compiler:Event Recorder 1.5.1, Compiler:I/O:STDOUT 1.2.0, Device:Startup 1.2.0
