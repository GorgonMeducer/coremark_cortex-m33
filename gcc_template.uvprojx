# Keil uVision project gcc_template.uvprojx, settings and files
target Cortex-M33_MPS2 (6160000::V6.16::ARMCLANG)
  device: IOTKit_CM33_FP_VHT ARM
  pack: Keil.V2M-MPS2_IOTKit_BSP.1.5.1
  cpu: IRAM(0x38000000,0x00200000) IRAM2(0x28200000,0x00200000) IROM(0x10000000,0x00200000) IROM2(0x00200000,0x00200000) CPUTYPE("Cortex-M33") FPU3(SFPU) DSP TZ CLOCK(12000000) ELITTLE
  output: gcc_template
  AfterMake: arm-none-eabi-size.exe ./Objects/gcc_template.elf
  group platform
    ./platform/: platform.c platform.h serial.c serial.h
  group app
    ./: main.c app_cfg.h
software components: CMSIS:CORE 5.6.0, Utilities:perf_counter:Benchmark 1.1.1, Utilities:perf_counter:Core 2.2.3, Compiler:Event Recorder 1.5.1, Device:Startup 1.2.0
